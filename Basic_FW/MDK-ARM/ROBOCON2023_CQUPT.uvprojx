# Keil uVision project ROBOCON2023_CQUPT.uvprojx, settings and files
target ROBOCON2023_CQUPT (5060960::V5.06 update 7 (build 960)::ARMCC)
  device: STM32F427IIHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.16.0
  cpu: IRAM(0x20000000-0x2002FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x81FFFFF)  CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: ROBOCON2023_CQUPT +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F427xx
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../Control;../Hardware;../Task;../Middlewares/Third_Party/LetterShell/src;../Middlewares/Third_Party/LetterShell/extensions/log;../Hardware/vesc_uart;../Middlewares/Third_Party;../Middlewares/Third_Party/LetterShell;..\Hardware\flashbd;..\Hardware;..\Hardware;..\Hardware\action_usart
  asm include: ..\Core\Inc;../Core/Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f427xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c freertos.c can.c dma.c spi.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c stm32f4xx_hal_timebase_tim.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_can.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group Middlewares/LetterShell
    ../Middlewares/Third_Party/LetterShell/src/: shell.c shell_cmd_list.c shell_companion.c shell_ext.c shell_port.c
    ../Middlewares/Third_Party/LetterShell/extensions/log/: log.c
  group Commend
    ../Middlewares/Third_Party/LetterShell/src/: commend.c
  group Hardware
    ../Hardware/: bsp_as5048.c bsp_can.c bsp_sbus.c vofa_lower.c bsp_vesc.c
    ../Hardware/action_usart/: action_usart.c
  group Task
    ../Task/: chassis_behaviour.c chassis_task.c task.c led_task.c test_task.c solenoid_task.c
  group Control
    ../Control/: pid.c kfifo.c
  group VESC_UART
    ../Hardware/vesc_uart/: bldc_interface.c bldc_interface_uart.c crc.c buffer.c packet.c
  group FlashDB
    ../Hardware/flashbd/Flashdb/: fdb.c fdb_kvdb.c fdb_tsdb.c fdb_utils.c kvdb_basic_sample.c kvdb_type_blob_sample.c kvdb_type_string_sample.c tsdb_sample.c
    ../Hardware/flashbd/FAL/: fal_partition.c
  group FAL
    ../Hardware/flashbd/FAL/: fal.c fal_flash.c fal_flash_stm32f4.c
software components: CMSIS:CORE 5.6.0
